# IAR project XC-GP4V1.0.ewp, settings and files
configuration XC-GP4V1.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030CC ST STM32F030CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030xC
  ICCARM.CCIncludePath2: ../Core/Inc; ..\User_Interface; ..\Elevator_Control; ..\Communication; ..\ShiftOut595; ..\ShiftIn165; ..\Config_File; ..\Delay; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XC-GP4V1.0.hex
  ILINK.IlinkOutputFile: XC-GP4V1.0.out
  ILINK.IlinkIcfFile: stm32f030xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Communication
    ../Communication/: Comm.c Comm.h
  group Config_File
    ../Config_File/: Config_File.h
  group Delay
    ../Delay/: delay.c delay.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Elevator_Control
    ../Elevator_Control/: Elevator_Control.c Elevator_Control.h
  group ShiftIn165
    ../ShiftIn165/: ShiftIn165.c ShiftIn165.h
  group ShiftOut595
    ../ShiftOut595/: ShiftOut595.c ShiftOut595.h
  group User_Interface
    ../User_Interface/: User_Interface.c User_Interface.h
